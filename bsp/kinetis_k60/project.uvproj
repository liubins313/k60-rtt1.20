# Keil uVision project project.uvproj, settings and files
target project (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: template +hex
  c flags: Optim=1
  c include: .;E:/RT-Thread_1.2.0/components/dfs;E:/RT-Thread_1.2.0/components/dfs/filesystems/nfs;E:/RT-Thread_1.2.0/components/dfs/include;E:/RT-Thread_1.2.0/components/drivers/include;E:/RT-Thread_1.2.0/components/finsh;E:/RT-Thread_1.2.0/components/init;E:/RT-Thread_1.2.0/components/net/lwip-1.4.1/src;E:/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/arch/include;E:/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/include;E:/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/include/ipv4;E:/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/include/netif;E:/RT-Thread_1.2.0/include;E:/RT-Thread_1.2.0/libcpu/arm/common;E:/RT-Thread_1.2.0/libcpu/arm/cortex-m4;Libraries\CMSIS\CM4\DeviceSupport;Libraries\Kinetis_StdPeriph\inc;applications;drivers
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --keep __rtmsym_*   --keep __fsym_*  --keep __rt_init*
  group Applications
    applications/: Jcprotocol.c application.c nfs.c startup.c thread_sleep.c uart_thread.c
  group Drivers
    drivers/: board.c ksz8041.c rtt_ksz8041.c rtt_serial.c uart3_4.c
  group K60_StdPeriph
    Libraries/CMSIS/CM4/DeviceSupport/: system_MK60D10.c
    Libraries/CMSIS/CM4/DeviceSupport/MDK-ARM/: startup_MK60D10.s
    Libraries/kinetis_StdPeriph/src/: adc.c can.c common.c cpuidy.c dac.c dma.c enet.c flexbus.c ftm.c gpio.c i2c.c lptmr.c pit.c rtc.c sd.c spi.c systick.c tsi.c uart.c vref.c wdog.c
  group Kernel
    E:/RT-Thread_1.2.0/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c module.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    E:/RT-Thread_1.2.0/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    E:/RT-Thread_1.2.0/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    E:/RT-Thread_1.2.0/components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    E:/RT-Thread_1.2.0/components/dfs/filesystems/nfs/: mount_clnt.c mount_xdr.c nfs_clnt.c nfs_xdr.c dfs_nfs.c
    E:/RT-Thread_1.2.0/components/dfs/filesystems/nfs/rpc/: auth_none.c clnt_generic.c clnt_udp.c rpc_prot.c pmap.c xdr.c xdr_mem.c
  group DeviceDrivers
    E:/RT-Thread_1.2.0/components/drivers/serial/: serial.c
    E:/RT-Thread_1.2.0/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c
  group finsh
    E:/RT-Thread_1.2.0/components/finsh/: shell.c symbol.c cmd.c msh_cmd.c msh.c
  group Components
    E:/RT-Thread_1.2.0/components/init/: components.c
  group LwIP
    E:/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    E:/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/arch/: sys_arch.c
    E:/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    E:/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    E:/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
